# Keil uVision project Intelligent_lamp_2018_YuXin.uvprojx, settings and files
target Intelligent_lamp_2018_YuXin (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Intelligent_lamp_2018_YuXin +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BASE_DRIVE;..\BASE_DEAL;..\CONTROL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group BASE_DEAL
    ../BASE_DEAL/: base_deal.c GY_53_deal.c TSL2561.c
  group BASE_DRIVE
    ../BASE_DRIVE/: led.c myiic.c pwm.c switch.c timer.c touch.c usart2.c
  group CONTROL
    ../CONTROL/: control.c light_dimmer.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group REDEME
    ../: README.TXT
